<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.10.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>doppler_corrector</value></param>
<param><key>title</key><value>GROUNDLINK Doppler Corrector</value></param>
<param><key>description</key><value>Apply Doppler correction to LEO IQ recordings using pre-computed profile</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>iq_source</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>file</key><value>input.raw</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>doppler_shift</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>2400000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>output_sink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>file</key><value>output_corrected.raw</value></param>
</block>
<connection><source_block_id>iq_source</source_block_id><sink_block_id>doppler_shift</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doppler_shift</source_block_id><sink_block_id>output_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
