<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.10.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>meteor_lrpt_receiver</value></param>
<param><key>title</key><value>GROUNDLINK Meteor-M2 LRPT Receiver</value></param>
<param><key>description</key><value>137.9 MHz LRPT receiver for Meteor-M2 weather satellite</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtl_source</value></param>
<param><key>sample_rate</key><value>900000</value></param>
<param><key>center_freq</key><value>137900000</value></param>
<param><key>rf_gain</key><value>40</value></param>
<param><key>bias_tee</key><value>False</value></param>
</block>
<block>
<key>analog_agc_cc</key>
<param><key>id</key><value>agc</value></param>
<param><key>rate</key><value>0.01</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>lpf</value></param>
<param><key>cutoff_freq</key><value>80000</value></param>
<param><key>transition_width</key><value>20000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>file</key><value>/tmp/meteor_lrpt_capture.raw</value></param>
</block>
<connection><source_block_id>rtl_source</source_block_id><sink_block_id>agc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>agc</source_block_id><sink_block_id>lpf</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpf</source_block_id><sink_block_id>file_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
