<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.10.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>iq_recorder</value></param>
<param><key>title</key><value>GROUNDLINK IQ Recorder</value></param>
<param><key>description</key><value>General-purpose IQ recorder for any frequency</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtl_source</value></param>
<param><key>sample_rate</key><value>2400000</value></param>
<param><key>center_freq</key><value>1694100000</value></param>
<param><key>rf_gain</key><value>40</value></param>
<param><key>bias_tee</key><value>True</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>head</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>24000000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>file</key><value>/tmp/iq_recording.raw</value></param>
</block>
<connection><source_block_id>rtl_source</source_block_id><sink_block_id>head</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>head</source_block_id><sink_block_id>file_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
