<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.10.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>snr_estimator</value></param>
<param><key>title</key><value>GROUNDLINK SNR Estimator</value></param>
<param><key>description</key><value>Estimate C/N₀ from IQ recording using PSD method</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>iq_source</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>file</key><value>/tmp/goes_lrit_capture.raw</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>throttle</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>2400000</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>psd_display</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>center_freq</key><value>1694100000</value></param>
<param><key>bandwidth</key><value>2400000</value></param>
<param><key>average</key><value>0.1</value></param>
</block>
<connection><source_block_id>iq_source</source_block_id><sink_block_id>throttle</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>throttle</source_block_id><sink_block_id>psd_display</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
