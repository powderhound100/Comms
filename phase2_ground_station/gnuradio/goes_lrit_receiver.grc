<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.10.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>goes_lrit_receiver</value></param>
<param><key>title</key><value>GROUNDLINK GOES LRIT Receiver</value></param>
<param><key>author</key><value>GROUNDLINK Project</value></param>
<param><key>description</key><value>RTL-SDR based GOES-18 LRIT receiver at 1694.1 MHz</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtl_source</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>2400000</value></param>
<param><key>center_freq</key><value>1694100000</value></param>
<param><key>rf_gain</key><value>40</value></param>
<param><key>if_gain</key><value>0</value></param>
<param><key>bb_gain</key><value>0</value></param>
<param><key>bias_tee</key><value>True</value></param>
</block>
<block>
<key>blocks_correctiq</key>
<param><key>id</key><value>dc_correct</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>lpf</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>cutoff_freq</key><value>200000</value></param>
<param><key>transition_width</key><value>50000</value></param>
<param><key>window</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_agc_cc</key>
<param><key>id</key><value>agc</value></param>
<param><key>rate</key><value>0.01</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>fft_display</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>center_freq</key><value>1694100000</value></param>
<param><key>bandwidth</key><value>2400000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>iq_recorder</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>file</key><value>/tmp/goes_lrit_capture.raw</value></param>
</block>
<connection><source_block_id>rtl_source</source_block_id><sink_block_id>dc_correct</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_correct</source_block_id><sink_block_id>lpf</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpf</source_block_id><sink_block_id>agc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>agc</source_block_id><sink_block_id>fft_display</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>agc</source_block_id><sink_block_id>iq_recorder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
